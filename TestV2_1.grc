options:
  parameters:
    author: Tyler Kovach
    generate_options: qt_gui
    id: TestV2_1
    output_language: python
    title: RTL-SDR reciever
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1536000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: tuning
    orient: Qt.Horizontal
    start: 0.5e6
    step: 10e3
    stop: 30e6
    value: 0.88e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    orient: Qt.Horizontal
    start: '0'
    step: '50e-3'
    stop: '10'
    value: '50e-3'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '6.25e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '1000'
    audio_stop: '8000'
    chan_rate: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/64
    decim: '32'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '12000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: 200e3
    fc: tuning
    fftsize: '2048'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0,direct_samp=2"'
    bb_gain0: '20'
    bw0: '200000'
    dc_offset_mode0: '2'
    freq0: tuning
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
