options:
  parameters:
    author: Tyler Kovach
    generate_options: qt_gui
    id: TestV8
    output_language: python
    title: RTL-SDR reciever
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: boltz
  id: variable
  parameters:
    value: '1.380648E-23'
  states: {}
- name: resistance
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1411200'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: tuning
    orient: Qt.Horizontal
    start: 0.5e6
    step: 10e3
    stop: 30e6
    value: 20.1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    orient: Qt.Horizontal
    start: '0'
    step: '50e-3'
    stop: '10'
    value: '50e-3'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/storage/Documents/3rd Year College/RJOVER/Data/test1.txt
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/(boltz*resistance*bandwidth*1000)
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: bandwidth
    fc: '0'
    fftsize: '2048'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '4000'
    srate: samp_rate/32
    type: float
    update_time: '1'
    ylabel: Temperature
    ymax: '-1E-3'
    ymin: '1E-3'
    yunit: '"Kk"'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '4000'
    srate: '44100'
    type: float
    update_time: '0.5'
    ymax: '1E-2'
    ymin: '-1E-2'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
