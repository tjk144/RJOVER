options:
  parameters:
    author: Tyler Kovach
    generate_options: qt_gui
    id: TestV1_0
    output_language: python
    title: RTL-SDR reciever
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: tuning
    orient: Qt.Horizontal
    start: 87.9e6
    step: 100e3
    stop: 108.1e6
    value: 108e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    orient: Qt.Horizontal
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '50e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: '240000'
    deviation: '75000'
    gain: '2'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    bw0: '200000'
    freq0: tuning
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
